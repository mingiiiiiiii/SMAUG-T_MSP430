<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MSP430_ASM_ntt.ewp</path>
    </project>
    <batchBuild />
</workspace>
