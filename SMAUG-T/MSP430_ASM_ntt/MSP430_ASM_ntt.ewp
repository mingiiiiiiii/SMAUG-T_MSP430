# IAR project MSP430_ASM_ntt.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F6779A MSP430F6779A
  General.GStackSize2: 20000
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f6779a.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: api.h cbd.c cbd.h ciphertext.c ciphertext.h dg.c dg.h fips202.c fips202.h hash.c hash.h hwt.c hwt.h indcpa.c indcpa.h io.c io.h kem.c kem.h key.c key.h main.c mont.s43 pack.c pack.h parameters.h poly.c poly.h randombytes.c randombytes.h test_intt.s43 test_ntt.s43 verify.c verify.h
